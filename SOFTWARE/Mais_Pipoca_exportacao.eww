<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Library.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Library_COIN.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Mais_Pipoca_exp.ewp</path>
  </project>
  <batchBuild/>
</workspace>


