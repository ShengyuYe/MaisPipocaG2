# IAR project Mais_Pipoca_exp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MaisPipoca_G2_2_1_3.HEX
  ILINK.IlinkOutputFile: Mais_Pipoca_exp.out
  ILINK.IlinkIcfFile: C:\repositorios\MaisPipocaG2\SOFTWARE\AirPopCorn.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group APLICACAO
    Aplicacao/: aplicacao.c embalagem.c faturamento.c InterfaceAjusteRelogio.c menu_acessorios.c menu_ajuste_relogio.c menu_avancado.c menu_configuracao.c menu_edita_flag.c menu_edita_inteiro.c menu_edita_listagem.c menu_faturamento.c menu_info_binaria.c menu_operacao.c menu_preparacao.c menu_rolagem.c menu_seleciona_lista.c menu_servico.c menu_teste_hardware.c menu_teste_mdb.c POST.c Preparacao.c tela_senha.c
  group DRIVERS/ANALOGICO
    Drivers/AmostragemAnalogica/: AmostraAnalogica.c
  group DRIVERS/CCTALK
    Drivers/CCTALK/: cctalk.c
  group DRIVERS/FILESYSTEM
    Drivers/FILESYSTEM/: dataflash_diskio.c diskio.c ff.c ffsystem.c ffunicode.c sd_diskio.c
    Drivers/SDCARD/: SDCARD.C SPI_WRAPPER_SD.C
  group DRIVERS/FLASH
    Drivers/sst25vf016b/: memoryWrapper.c spi_wrapper.c sst25vf016b.c
  group DRIVERS/IMPRESSORA
    Drivers/Impressora/: impressora.c
  group DRIVERS/MDB
    Drivers/MDB/: mdb.c mdb_bill.c mdb_cashless.c mdb_coin.c mdb_uart.c
  group DRIVERS/PLAYERWAVE
    Drivers/PlayerWave/: PlayerWave.c
  group DRIVERS/PROTOCOLO
    ../../pegabola_g2/FIRMWARE/app/Protocolo/: DESCRITIVO_DXTNET.TXT
    Drivers/Protocolo/: Protocolo.c
  group DRIVERS/RECORD_FILE_SYSTEM
    Drivers/RECORD_FILE_SYSTEM/: record_file_system.c
  group DRIVERS/RTC
    Drivers/RTC/: RTC.C
  group DRIVERS/SERIAL_MUX
    Drivers/SERIAL_MUX/: serial_mux.c
  group DRIVERS/TECLADO
    Drivers/Teclado/: Teclado.c
  group DRIVERS/UART
    Drivers/UARTS/: uart.c
  group DRIVERS/WATCHDOG
    Drivers/WATCHDOG/: WATCHDOG.C
  group DRIVERS/WH1602
    Drivers/WH1602/: WH1602.C
  group DRIVERS/WH1602_2
    Drivers/WH1602_2/: WH1602_2.C
  group HISTORICO_PRECOS
    Historico_precos/: fila_troca_preco.c flash_queue.c
  group IU
    IU/: leds.c
  group KERNEL/BOARD
    Board/: Board.c
  group KERNEL/RTOS
    Kernel/: heap_1.c list.c port.c portasm.s queue.c tasks.c
  group KERNEL/TARGET
    ./: cstartup_M.asm main.c
  group MESSAGENS
    Strings/: mensagens.H strings.c strings.h
  group PAGAMENTOS
    Drivers/Pagamentos/: BV20.c Pagamentos.c Supervisao_MDB.c Supervisao_mdb_bill.c supervisao_mdb_cashless.c Supervisao_mdb_coin.c
  group PARAMETROS
    Parametros/: parametros.c
    parametros/: parametros.h
  group POTENCIA
    Potencia/: ControleTemperatura.c Potencia.c
  group RELATORIO
    Relatorio/: Relatorio.c
